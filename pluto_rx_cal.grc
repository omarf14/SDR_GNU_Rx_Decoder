options:
  parameters:
    author: gs
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: pluto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: TED_gain
  id: variable_qtgui_range
  parameters:
    start: '0.01'
    step: '0.01'
    stop: '0.1'
    value: '0.02'
  states: {}
- name: bpsk_o
  id: variable_constellation
  parameters:
    precision: '2'
    type: bpsk
  states: {}
- name: bpsk_o_2
  id: variable_constellation
  parameters:
    const_points: '[-1-0j, +1+0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: bwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '10000'
    stop: 10e6
    value: bw
  states: {}
- name: costas_loop
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0.05'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 2e3
    stop: 2.5e9
    value: 2.23e9
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '150'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_loop
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.002'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: 'True'
    threshold: '-70'
    type: complex
  states: {}
- name: blocks_correctiq_auto_0_0
  id: blocks_correctiq_auto
  parameters:
    freq: lo_freq
    gain: '1.5'
    samp_rate: samp_rate
    syncWindow: '2'
  states: {state: disabled}
- name: blocks_correctiq_auto_0_0_0
  id: blocks_correctiq_auto
  parameters:
    freq: freq
    gain: '1.5'
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '2047'
    vector_input: 'True'
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_loop
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '0.1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-20000'
    decim: '1'
    samp_rate: samp_rate
    type: ccc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2230000000'
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1000000'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '0.35'
    cutoff_freq: bwidth*1.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '9000000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: PS_BPSK
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PS_BPSK
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [blocks_correctiq_auto_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', blocks_correctiq_auto_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
