options:
  parameters:
    author: gs
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: pluto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: TED_gain
  id: variable_qtgui_range
  parameters:
    start: '0.01'
    step: '0.01'
    stop: '0.1'
    value: '0.02'
  states: {}
- name: bpsk_o
  id: variable_constellation
  parameters:
    precision: '2'
    type: bpsk
  states: {}
- name: bpsk_o_2
  id: variable_constellation
  parameters:
    const_points: '[-1-0j, +1+0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: bwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '10000'
    stop: 10e6
    value: bw
  states: {}
- name: costas_loop
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 2e3
    stop: 2.5e9
    value: 2.23e9
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '150'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_loop
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.001'
    stop: '0.05'
    value: '0.008'
  states: {}
- name: variable_tag_object_0
  id: variable_tag_object
  parameters:
    key: pmt.intern("key")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("value")
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: 'True'
    threshold: '-65'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_correctiq_auto_0_0
  id: blocks_correctiq_auto
  parameters:
    freq: lo_freq
    gain: '1.5'
    samp_rate: samp_rate
    syncWindow: '2'
  states: {state: disabled}
- name: blocks_correctiq_auto_0_0_0
  id: blocks_correctiq_auto
  parameters:
    freq: freq
    gain: '1.5'
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    maxoutbuf: '8192'
    packet_len: '4144'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: ac_found
    name: ac_found
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: ac_found
    maxoutbuf: '8192'
    type: byte
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1011100111111000101100100010000010110001110011110001001010111100'
    tagname: ac_found
    threshold: '14'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_loop
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '0.1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '250000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2230000000'
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1000000'
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '0.35'
    cutoff_freq: bwidth*1.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_CLIENT
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    maxoutbuf: '8192'
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: PS_BPSK
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SS_BPSK
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PS_BPSK
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: SS_BPSK
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_float_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_correctiq_auto_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_vector_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', virtual_sink_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_1, pdus, network_socket_pdu_0, pdus]
- [virtual_source_0, '0', blocks_correctiq_auto_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
